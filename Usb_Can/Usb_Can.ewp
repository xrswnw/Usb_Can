# IAR project Usb_Can.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072CB ST STM32F072CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F070xB; USE_STDPERIPH_DRIVER; _ANYID_STM32_
  ICCARM.CCIncludePath2: ..\STM32F0xx_StdPeriph_Lib_V1.6.0\core; ..\STM32F0xx_StdPeriph_Lib_V1.6.0\startup; ..\STM32F0xx_StdPeriph_Lib_V1.6.0\inc; ..\USB\App\inc; ..\USB\Library\inc; ..\USB\Device\inc; ..\USB\Class\inc; ..\Main\inc; ..\User\inc; E:\AnyID\AnyID_Embedded\V1.1.0\AnyID_lib_V1.1.0\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Usb_Can.hex
  ILINK.IlinkOutputFile: Usb_Can.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CmSis
    ../STM32F0xx_StdPeriph_Lib_V1.6.0/startup/: system_stm32f0xx.c
  group EwArm
    ../STM32F0xx_StdPeriph_Lib_V1.6.0/startup/: startup_stm32f070xb.s
  group Main
    ../Main/src/: main.c stm32f0xx_it.c
  group StdPeriph_Lib
    ../STM32F0xx_StdPeriph_Lib_V1.6.0/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Usb/App
    ../USB/App/src/: usb_bsp.c usbd_desc.c usbd_pwr.c usbd_usr.c
  group Usb/Class
    ../USB/Class/src/: usbd_hid_core.c
  group Usb/Device
    ../USB/Device/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group Usb/Lib
    ../USB/Library/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group User
    ../../../AnyID_Embedded/V1.1.0/AnyID_lib_V1.1.0/src/: AnyID_Stdlib.c
    ../User/src/: Can_HL.c Device.c SysCfg.c SysTick.c Usb_HL.c
